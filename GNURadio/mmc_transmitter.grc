<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>modular_clock_transmitter</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>16384</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freqhop_rate</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_channels</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>multihop_channel_to_freq</key>
<param><key>id</key><value>multihop_channel_to_freq_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>num_channels</key><value>num_channels</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>multihop_freqhop_signal_source</key>
<param><key>id</key><value>multihop_freqhop_signal_source_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freqhop</key><value>freqhop_rate</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>multihop_modular_clock_rendezvous</key>
<param><key>id</key><value>multihop_modular_clock_rendezvous_0</value></param>
<param><key>num_channels</key><value>num_channels</value></param>
<param><key>transmitter</key><value>True</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>32</value></param>
<param><key>freq0</key><value>100e6</value></param>
<param><key>if_gain0</key><value>32</value></param>
<param><key>gain0</key><value>14</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>multihop_channel_to_freq_0</source_block_id><sink_block_id>multihop_freqhop_signal_source_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multihop_freqhop_signal_source_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multihop_freqhop_signal_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multihop_modular_clock_rendezvous_0</source_block_id><sink_block_id>multihop_channel_to_freq_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
